# Keil uVision project ISP_UART.uvprojx, settings and files
target ISP_UART (6220000::V6.22::ARMCLANG)
  device: M032SE3AE Nuvoton
  pack: Nuvoton.NuMicroM0_DFP.1.0.2
  cpu: IRAM(0x20000000-0x20003FFF) IROM(0-0x1FFFF) CLOCK(48000000) CPUTYPE("Cortex-M0")
  output: ISP_UART
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: Optim=6 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c include: ..\..\..\..\Library\Device\Nuvoton\M031\Include;..\..\..\..\Library\StdDriver\inc;..\..\..\..\Library\CMSIS\Include;..\
  library: MicroLIB
  memory RVCT4: ROM 0x100000 size 0x1000
  memory RVCT9: RAM 0x20000000 size 0x4000
  link misc: --map --first='startup_M031Series_user.o(RESET)' --datacompressor=off --info=inline --entry Reset_Handler
  group CMSIS
    ../../../../Library/Device/Nuvoton/M031/Source/: system_M031Series.c
    ./: startup_M031Series_user.s
  group User
    ../: fmc_user.c isp_user.c targetdev.c uart_transfer.c main_LDROM.c
  group Library
    ../../../../Library/StdDriver/src/: clk.c uart.c
