# Keil uVision project JIG-8FT-P1.uvprojx, settings and files
target Target_1 (6220000::V6.22::ARMCLANG)
  device: M032SE3AE Nuvoton
  pack: Nuvoton.NuMicroM0_DFP.1.0.2
  cpu: IRAM(0x20000000,0x4000) IROM(0x00000000,0x20000) IROM2(0x00100000,0x1000) CPUTYPE("Cortex-M0") CLOCK(12000000)
  output: JIG-8FT-P1
  AfterMake: fromelf --bin --output="./firmware/M031/APROM/m031_V.bin" !L
  c flags: Optim=2 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=3
  c misc: -finput-charset=utf-8
  c include: .\Library\CMSIS\Include;.\Library\Device\Nuvoton\M031\Include;.\Library\StdDriver\inc
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT5: ROM 0x100000 size 0x1000
  memory RVCT9: RAM 0x20000000 size 0x4000
  link misc: --entry Reset_Handler
  group CMSIS
    ./Library/Device/Nuvoton/M031/Source/: system_M031Series.c
    ./Library/Device/Nuvoton/M031/Source/ARM/: startup_M031Series.s
  group Library
    ./Library/StdDriver/src/: acmp.c adc.c bpwm.c clk.c crc.c ebi.c fmc.c gpio.c i2c.c pdma.c pwm.c qspi.c retarget.c rtc.c spi.c sys.c timer.c uart.c usbd.c usci_i2c.c usci_spi.c usci_uart.c wdt.c wwdt.c
  group User
    ./: main.c INA237.c OLED.c RV3028.c Wiegand_TK2.c descriptors.c hid_kb.c
